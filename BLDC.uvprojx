# Keil uVision project BLDC.uvprojx, settings and files
target STM32F446RET6B (6140000::V6.14::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BLDC +hex
  c flags: Optim=5 OneElfS=1 v6Lang=6 v6LangP=9 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Common
    ./: main.c define.h
  group Init
    ./: init.c init.h
  group led
    ./: led.h
  group delay
    ./: delay.c delay.h
  group print
    ./: print.h print.c
  group complex
    ./: complex.h complex.c
  group list
    ./: list.h list.c
  group dmaTransfer
    ./: dmaTransfer.h dmaTransfer.c
  group irq
    ./: irq.h irq.c
  group phase
    ./: phase.h
  group motor
    ./: motor.h motor.c
  group bluetooth
    ./: bluetooth.h bluetooth.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
